## config/pixctrl_defconfig
```kconfig
CONFIG_APP_SAMPLE=y
CONFIG_TOOLCHAIN=llvm
CONFIG_LIBRARY_PIXELCTRL=y
CONFIG_LIBRARY_PIXELCTRL_PARALLER=n
CONFIG_LIBRARY_PIXELCTRL_SIMD_NEON=n
```
